# Keil uVision project lab1.uvproj, settings and files
target Target 1 (MCS-51)
  device: ADuC812 Analog Devices
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x1FFF) CLOCK(11059200) DPX
  output: lab1
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: lab2.c
target Target 2 (MCS-51)
  device: ADuC812 Analog Devices
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x1FFF) CLOCK(11059200) DPX
  output: lab1
  c flags: Optimize=8 SizeSpeed=1
